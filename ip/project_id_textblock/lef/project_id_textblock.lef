VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO project_id_textblock
  CLASS BLOCK ;
  FOREIGN project_id_textblock ;
  ORIGIN 3.280 10.800 ;
  SIZE 173.750 BY 51.720 ;
  OBS
      LAYER li1 ;
        RECT 0.0 0.0 173.750 51.720 ;
      LAYER met1 ;
        RECT 0.0 0.0 173.750 51.720 ;
      LAYER met2 ;
        RECT 0.0 0.0 173.750 51.720 ;
      LAYER met3 ;
        RECT 0.0 0.0 173.750 51.720 ;
      LAYER met4 ;
        RECT 0.0 0.0 173.750 51.720 ;
      LAYER met5 ;
        RECT 0.0 0.0 173.750 51.720 ;
  END
END project_id_textblock
END LIBRARY

